# Keil uVision project USART.uvproj, settings and files
target USART (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\..\USART;..\..\..\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\STM32F4xx_DSP_StdPeriph_Lib_V1.6.0\Libraries\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../: main.c stm32f4xx_it.c my_usart.c my_usart.h
    ../../../STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h
  group STM32F4xx_DSP_StdPeriph_Lib_V1.6.0
    ../../../STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_spi.c
    ../../../STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../../../STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_exti.h stm32f4xx_spi.h
  group CMISIS
    ../: system_stm32f4xx.c
    ../../../STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h
    ../../../STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c
  group MDK-ARM
    ../../../STM32F4xx_DSP_StdPeriph_Lib_V1.6.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
